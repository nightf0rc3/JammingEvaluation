options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: evaluation_receiver
    output_language: python
    realtime_scheduling: '1'
    title: IEEE 802.15.4 Receiver
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 2470e6
  states: {}
- name: gain
  id: variable
  parameters:
    value: '0.9'
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /Users/colinkater/Documents/Uni/Master/FSS22/MasterArbeit/sdr-jrb/raw/raw.raw
    type: complex
  states: {}
- name: ieee802_15_4_oqpsk_phy_recv_0
  id: ieee802_15_4_oqpsk_phy_recv
  parameters: {}
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    bw0: '2000000'
    center_freq0: freq
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_addr: serial=3180E09
    dev_args: '""'
    gain0: gain
    iq_imbal_enb0: '""'
    norm_gain0: 'True'
    samp_rate: '4000000'
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', blocks_file_sink_1, '0']
- [uhd_usrp_source_0, '0', ieee802_15_4_oqpsk_phy_recv_0, '0']

metadata:
  file_format: 1
